/*
 * CFile1.c
 *
 * Created: 3/1/2024 11:19:03 PM
 *  Author: Ali
 */ 
/**********************************************************************************************************************
 *  FILE DESCRIPTION
 *  -----------------------------------------------------------------------------------------------------------------*/
/**        \file  FileName.c
 *        \brief  
 *
 *      \details  
 *
 *
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  INCLUDES
 *********************************************************************************************************************/
#include "KeyPad_Core.h"

/**********************************************************************************************************************
*  LOCAL MACROS CONSTANT\FUNCTION
*********************************************************************************************************************/
#define F_CPU 16000000U
#include <util/delay.h>
/**********************************************************************************************************************
 *  LOCAL DATA 
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  GLOBAL DATA
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  LOCAL FUNCTION PROTOTYPES
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  LOCAL FUNCTIONS
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  GLOBAL FUNCTIONS
 *********************************************************************************************************************/


/******************************************************************************
* \Syntax          : Std_ReturnType FunctionName(AnyType parameterName)        
* \Description     : Describe this service                                    
*                                                                             
* \Sync\Async      : Synchronous                                               
* \Reentrancy      : Non Reentrant                                             
* \Parameters (in) : parameterName   Parameter Describtion                     
* \Parameters (out): None                                                      
* \Return value:   : Std_ReturnType  E_OK
*                                    E_NOT_OK                                  
*******************************************************************************/
void KeyPad_Init(void)
{
	DIO_WriteChannel(KEYPAD_ROW_0 , PIN_HIGH);
	DIO_WriteChannel(KEYPAD_ROW_1 , PIN_HIGH);
	DIO_WriteChannel(KEYPAD_ROW_2 , PIN_HIGH);
	DIO_WriteChannel(KEYPAD_ROW_3 , PIN_HIGH);
}

/******************************************************************************
* \Syntax          : Std_ReturnType FunctionName(AnyType parameterName)
* \Description     : Describe this service
*
* \Sync\Async      : Synchronous
* \Reentrancy      : Non Reentrant
* \Parameters (in) : parameterName   Parameter Describtion
* \Parameters (out): None
* \Return value:   : Std_ReturnType  E_OK
*                                    E_NOT_OK
*******************************************************************************/
uint8 KeyPad_GetValue(void)
{
	uint8 Col_Loc = 0 , Row_Loc = 0 , Button_Value = 0 , Temp = 2;
	
	for(Row_Loc= ROW_INIT ; Row_Loc <= ROW_FINAL  ;Row_Loc++)
	{
		DIO_WriteChannel(Row_Loc , PIN_LOW);
		
			for(Col_Loc= COL_INIT ; Col_Loc <= COL_FINAL  ;Col_Loc++)
			{
				DIO_ReadChannel(Col_Loc , &Temp);
				
				if(Temp == KEYPAD_PRESSED)
				{
					Button_Value = KEYPAD_VALUES[Row_Loc - ROW_INIT][Col_Loc - COL_INIT];
					
					while(Temp == KEYPAD_PRESSED)
					{
						DIO_ReadChannel(Col_Loc , &Temp);
					}
					_delay_ms(10);
				}
			}
		DIO_WriteChannel(Row_Loc , PIN_HIGH);
		
	}
	return Button_Value;
}

/**********************************************************************************************************************
 *  END OF FILE: 
 *********************************************************************************************************************/
